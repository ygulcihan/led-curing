# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: NUC029FAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: flasher +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC029FAE\Include;..\Library\StdDriver\inc;..\Library\Sinyalizasyon\inc;..\Template
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_NUC029FAE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC029FAE/Source/: system_NUC029FAE.c
    ../Library/Device/Nuvoton/NUC029FAE/Source/ARM/: startup_NUC029FAE.s
  group Library
    ../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c timer.c pwm.c fmc.c
    ../Library/Sinyalizasyon/src/: buttonLib.c ticker.c
  group User
    ../: main.c flasher.c flasher.h main.h
